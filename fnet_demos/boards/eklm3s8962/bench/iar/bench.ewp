# IAR project bench.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S8962 TexasInstruments LM3S8962
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; FNET_CFG_COMP_IAR=1; FNET_CFG_CPU_LM3S8962=1; FNET_CFG_CPU_SERIAL_PORT_DEFAULT=0u
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../common/startup/CMSIS; ../../../../common/startup; ../../../../common/startup/LM3S8962; ..; ../../../../src/bench; ../../../../../fnet_stack; ../../../../common/fnet_application
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; FNET_CFG_COMP_IAR=1; FNET_CFG_CPU_MK64FN1=1
  AARM.AUserIncludes: ../../../../src/bench; ../../../../../fnet_stack
  OBJCOPY.OOCOutputFile: fnet_firmware.srec
  ILINK.IlinkOutputFile: bench.out
  ILINK.IlinkIcfFile: ..\..\..\..\common\startup\LM3S8962\iar\LM3S8962_Debug.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 NXP MK64FN1M0xxx12
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG; FNET_CFG_COMP_IAR=1; CPU_MK64FN1M0VMD12; FRDM_K64F; FREEDOM; FNET_CFG_CPU_MK64FN1=1; FNET_CFG_CPU_SERIAL_PORT_DEFAULT=0u
  ICCARM.CCIncludePath2: ../../../../common/startup/CMSIS; ../../../../common/startup; ../../../../common/startup/MK64F12; ..; ../../../../src/bench; ../../../../../fnet_stack; ../../../../common/fnet_application
  ICCARM.CCOptLevel: 3
  AARM.ADefines: FNET_CFG_COMP_IAR=1; FNET_CFG_CPU_MK64FN1=1
  group fnet_application
    ../../../../common/fnet_application/: fapp.c fapp.h fapp_autoip.c fapp_autoip.h fapp_bench.c fapp_bench.h fapp_config.h fapp_dhcp.c fapp_dhcp.h fapp_dns.c fapp_dns.h fapp_fs.c fapp_fs.h fapp_fs_image.c fapp_http.c fapp_http.h fapp_link.c fapp_link.h fapp_llmnr.c fapp_llmnr.h fapp_mdns.c fapp_mdns.h fapp_mem.c fapp_mem.h fapp_netif.c fapp_netif.h fapp_params.c fapp_params.h fapp_params_prv.h fapp_ping.c fapp_ping.h fapp_prv.h fapp_setget.c fapp_setget.h fapp_shell.c fapp_shell.h fapp_sntp.c fapp_sntp.h fapp_telnet.c fapp_telnet.h fapp_tftp.c fapp_tftp.h fapp_wifi.c fapp_wifi.h
  group fnet_stack
    ../../../../../fnet_stack/: fnet.h fnet_config.h
  group fnet_stack/port/compiler
    ../../../../../fnet_stack/port/compiler/: fnet_comp.h fnet_comp_asm.h fnet_comp_config.h
  group fnet_stack/port/cpu
    ../../../../../fnet_stack/port/cpu/: fnet_cpu.c fnet_cpu.h fnet_cpu_config.h
  group fnet_stack/port/cpu/lm3s
    ../../../../../fnet_stack/port/cpu/lm3s/: fnet_lm3s.h fnet_lm3s8962_config.h fnet_lm3s_config.h fnet_lm3s_eth.c fnet_lm3s_flash.c fnet_lm3s_serial.c fnet_lm3s_timer.c
  group fnet_stack/service
    ../../../../../fnet_stack/service/: fnet_service.c fnet_service.h fnet_service_config.h
  group fnet_stack/service/autoip
    ../../../../../fnet_stack/service/autoip/: fnet_autoip.c fnet_autoip.h fnet_autoip_config.h
  group fnet_stack/service/dhcp
    ../../../../../fnet_stack/service/dhcp/: fnet_dhcp.c fnet_dhcp_cln.c fnet_dhcp_cln.h fnet_dhcp_config.h fnet_dhcp_prv.h fnet_dhcp_srv.c fnet_dhcp_srv.h
  group fnet_stack/service/dns
    ../../../../../fnet_stack/service/dns/: fnet_dns.c fnet_dns.h fnet_dns_config.h fnet_dns_prv.h
  group fnet_stack/service/flash
    ../../../../../fnet_stack/service/flash/: fnet_flash.c fnet_flash.h fnet_flash_config.h
  group fnet_stack/service/fs
    ../../../../../fnet_stack/service/fs/: fnet_fs.c fnet_fs.h fnet_fs_config.h fnet_fs_prv.h fnet_fs_rom.c fnet_fs_rom.h fnet_fs_root.c fnet_fs_root.h
  group fnet_stack/service/http
    ../../../../../fnet_stack/service/http/: fnet_http.c fnet_http.h fnet_http_auth.c fnet_http_auth.h fnet_http_auth_prv.h fnet_http_cgi.c fnet_http_cgi.h fnet_http_config.h fnet_http_get.c fnet_http_post.c fnet_http_post.h fnet_http_prv.h fnet_http_ssi.c fnet_http_ssi.h fnet_http_ssi_prv.h
  group fnet_stack/service/link
    ../../../../../fnet_stack/service/link/: fnet_link.c fnet_link.h fnet_link_config.h
  group fnet_stack/service/llmnr
    ../../../../../fnet_stack/service/llmnr/: fnet_llmnr.c fnet_llmnr.h fnet_llmnr_config.h
  group fnet_stack/service/mdns
    ../../../../../fnet_stack/service/mdns/: fnet_mdns.c fnet_mdns.h fnet_mdns_config.h
  group fnet_stack/service/ping
    ../../../../../fnet_stack/service/ping/: fnet_ping.c fnet_ping.h fnet_ping_config.h
  group fnet_stack/service/serial
    ../../../../../fnet_stack/service/serial/: fnet_serial.c fnet_serial.h fnet_serial_config.h
  group fnet_stack/service/shell
    ../../../../../fnet_stack/service/shell/: fnet_shell.c fnet_shell.h fnet_shell_config.h
  group fnet_stack/service/sntp
    ../../../../../fnet_stack/service/sntp/: fnet_sntp.c fnet_sntp.h fnet_sntp_config.h
  group fnet_stack/service/telnet
    ../../../../../fnet_stack/service/telnet/: fnet_telnet.c fnet_telnet.h fnet_telnet_config.h
  group fnet_stack/service/tftp
    ../../../../../fnet_stack/service/tftp/: fnet_tftp.h fnet_tftp_cln.c fnet_tftp_cln.h fnet_tftp_config.h fnet_tftp_srv.c fnet_tftp_srv.h
  group fnet_stack/service/tls
    ../../../../../fnet_stack/service/tls/: fnet_tls.c fnet_tls.h fnet_tls_config.h
  group fnet_stack/stack
    ../../../../../fnet_stack/stack/: fnet_arp.c fnet_arp.h fnet_arp_prv.h fnet_assert.h fnet_checksum.c fnet_checksum.h fnet_debug.h fnet_error.c fnet_error.h fnet_eth.c fnet_eth.h fnet_eth_prv.h fnet_icmp4.c fnet_icmp4.h fnet_icmp6.c fnet_icmp6.h fnet_igmp.c fnet_igmp.h fnet_inet.c fnet_inet.h fnet_ip.c fnet_ip4.c fnet_ip4.h fnet_ip4_prv.h fnet_ip6.c fnet_ip6.h fnet_ip6_prv.h fnet_ip_prv.h fnet_isr.c fnet_isr.h fnet_loop.c fnet_loop.h fnet_mempool.c fnet_mempool.h fnet_mld.c fnet_mld.h fnet_nd6.c fnet_nd6.h fnet_netbuf.c fnet_netbuf.h fnet_netif.c fnet_netif.h fnet_netif_prv.h fnet_prot.c fnet_prot.h fnet_raw.c fnet_raw.h fnet_socket.c fnet_socket.h fnet_socket_prv.h fnet_stack.c fnet_stack.h fnet_stack_config.h fnet_stack_prv.h fnet_stdlib.c fnet_stdlib.h fnet_tcp.c fnet_tcp.h fnet_timer.c fnet_timer.h fnet_timer_prv.h fnet_udp.c fnet_udp.h fnet_wifi.c fnet_wifi.h fnet_wifi_prv.h
  group source
    ../../../../src/bench/: fapp_user_config.h fnet_user_config.h main.c
  group startup
    ../../../../common/startup/LM3S8962/: lm3s8962.h
  group startup/iar
    ../../../../common/startup/LM3S8962/iar/: startup_lm3s.c
